<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\wm_gsm_mini_v3.ewp</path>
  </project>
  <batchBuild />
</workspace>
